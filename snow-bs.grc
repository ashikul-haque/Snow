options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: fft_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 450e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '-110'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    marker1: '0'
    size: fft_size
    srate: fft_size
    style1: '3'
    type: float
    ymax: '10'
    ymin: '-10'
  states: {}
- name: snow_demod_0
  id: snow_demod
  parameters:
    enable_log: 'False'
    fft_size: fft_size
    subcarriers: '[16, 32, 48]'
    threshold: '3'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: 6e6
    center_freq0: freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: tx_gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_vector_to_stream_0, '0', snow_demod_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [snow_demod_0, '0', qtgui_time_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
